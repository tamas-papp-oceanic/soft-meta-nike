SUMMARY = "Nike NGINX configuration"

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
